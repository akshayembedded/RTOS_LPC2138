# Keil uVision project rtosintro.uvproj, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC2138 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: rtosintro
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Users\aksha\Downloads\FreeRTOS\Source;C:\Users\aksha\Downloads\FreeRTOS\Source\include;C:\Users\aksha\Downloads\FreeRTOS\Source\portable\MemMang;C:\Users\aksha\Downloads\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx
  asm include: C:\Users\aksha\Downloads\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    C:/Users/aksha/Downloads/FreeRTOS/Demo/ARM7_LPC2129_Keil_RVDS 2 (Led and UART simple)/: Startup.s
    ./: first.c ledblink.c
  group RTOS
    C:/Users/aksha/Downloads/FreeRTOS/Source/: list.c queue.c tasks.c
    C:/Users/aksha/Downloads/FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
    C:/Users/aksha/Downloads/FreeRTOS/Source/portable/MemMang/: heap_4.c
